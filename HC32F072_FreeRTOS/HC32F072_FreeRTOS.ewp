# IAR project HC32F072_FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: driver\inc; freertos-7.4.2\Source\include; freertos-7.4.2\Source\portable; freertos-7.4.2\Source\portable\MemMang; freertos-7.4.2\Source\portable\RVDS; freertos-7.4.2\Source\portable\RVDS\ARM_CM0; freertos-7.4.2\Source\CMSIS_RTOS; mcu\common; User; $TOOLKIT_DIR$\CMSIS\Core\Include; App; hardware
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: freertos-7.4.2\Source\CMSIS_RTOS; freertos-7.4.2\Source\include; freertos-7.4.2\Source\portable\MemMang; freertos-7.4.2\Source\portable\RVDS\ARM_CM0; freertos-7.4.2\Source\portable\RVDS; freertos-7.4.2\Source\portable; freertos-7.4.2\Source; mcu\common; driver\inc; driver\src; User
  ILINK.IlinkOutputFile: HC32F072_FreeRTOS.out
  ILINK.IlinkIcfFile: mcu\EWARM\config\hc32f072.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group FreeRTOS
    freertos-7.4.2/Source/CMSIS_RTOS/: cmsis_os.c
    freertos-7.4.2/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    freertos-7.4.2/Source/portable/MemMang/: heap_4.c
    freertos-7.4.2/Source/portable/RVDS/ARM_CM0/: port.c portasm.s
  group Hardware
    hardware/: hd_adc.c hd_adc.h hd_can.c hd_can.h hd_gpio.c hd_gpio.h hd_gpt_timer.c hd_gpt_timer.h hd_pca.c hd_pca.h hd_uart1.c hd_uart1.h
  group lib
    driver/src/: adc.c adt.c aes.c bgr.c bt.c can.c crc.c dac.c ddl.c debug.c dmac.c flash.c gpio.c hdiv.c i2c.c i2s.c lpm.c lpuart.c lvd.c opa.c pca.c ram.c reset.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group MCU
    mcu/common/: interrupts_hc32f072.c system_hc32f072.c
    mcu/EWARM/: startup_hc32f072.s
  group User
    App/: app_task.c main.c
