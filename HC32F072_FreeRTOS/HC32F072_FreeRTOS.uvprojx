# Keil uVision project HC32F072_FreeRTOS.uvprojx, settings and files
target HC32F072_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F072PATA HDSC
  pack: HDSC.HC32F072.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HC32F072_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1
  c include: .\driver\inc;.\driver\src;.\freertos-7.4.2\Source\CMSIS_RTOS;.\freertos-7.4.2\Source\include;.\freertos-7.4.2\Source\portable\MemMang;.\freertos-7.4.2\Source\portable\RVDS\ARM_CM0\MDK;.\freertos-7.4.2\Source\portable\RVDS\ARM_CM0;.\freertos-7.4.2\Source\portable\RVDS;.\freertos-7.4.2\Source\portable;.\freertos-7.4.2\Source;.\freertos-7.4.2;.\mcu\common\MDK;.\mcu\common;.\mcu\MDK;.\hardware;.\App
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group App
    ./App/: main.c app_task.h app_task.c
  group FreeRTOS
    ./freertos-7.4.2/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./freertos-7.4.2/Source/portable/RVDS/ARM_CM0/MDK/: port.c
    ./freertos-7.4.2/Source/CMSIS_RTOS/: cmsis_os.c
    ./freertos-7.4.2/Source/portable/MemMang/: heap_4.c
  group lib
    ./driver/src/: adc.c adt.c aes.c bgr.c bt.c can.c crc.c dac.c ddl.c debug.c dmac.c flash.c gpio.c hdiv.c i2c.c i2s.c lpm.c lpuart.c lvd.c opa.c pca.c ram.c reset.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group MCU
    ./mcu/common/: interrupts_hc32f072.c system_hc32f072.c
    ./mcu/MDK/: startup_hc32f072.s
  group Hardware
    ./hardware/: hd_gpt_timer.c hd_gpt_timer.h hd_gpio.c hd_gpio.h hd_pca.c hd_pca.h hd_uart1.c hd_uart1.h hd_can.c hd_can.h hd_adc.c hd_adc.h
software components: CMSIS:CORE 5.2.0
